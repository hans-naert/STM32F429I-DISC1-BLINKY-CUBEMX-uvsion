# Keil uVision project blinky-cubemx.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: blinky-cubemx
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ./
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: retarget_stdio.c oefening1.c oefening2.c oefening3.c oefening4.c oefening5.c oefening6.c oefening7.c oefening8.c oefening9.c
  group :CubeMX:CubeMX
    ./STM32CubeMX/Target_1/STM32CubeMX/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c stm32f4xx_hal_timebase_tim.c
    ./STM32CubeMX/Target_1/STM32CubeMX/MDK-ARM/: startup_stm32f429xx.s
  group :CubeMX:STM32 HAL Driver
    ./STM32CubeMX/Target_1/STM32CubeMX/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDIN:Custom 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.2.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, CMSIS Driver:USART 3.0.0, Device:CubeMX 1.0.0
